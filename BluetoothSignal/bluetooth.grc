options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: Frequency
  id: variable
  parameters:
    value: 2.402e9
  states: {state: disabled}
- name: Frequency
  id: variable
  parameters:
    value: 2.026e9
  states: {state: disabled}
- name: Frequency
  id: variable
  parameters:
    value: 2.48e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\admin\Desktop\RF-Fingerprint-Extraction-for-Bluetooth\BluetoothSignal\signal\channal39_1
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: Frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '3000000'
    fc: Frequency
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
